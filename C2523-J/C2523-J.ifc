Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-02-05T14:40:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 05 14:40:32 2024 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\53db74a7-55e1-43ac-8738-eac31773d981\3fa4a1a5-08b9-4618-966b-e31735d4631d\ifc * Database version: 5507 * Database creation date: Mon Feb 05 14:40:29 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 05 14:40:30 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 05 14:40:30 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: C2523-J:C2523-J, C2523-J:C2523-J:811811
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: C2523-J
Pset_DistributionFlowElementCommon - Reference: C2523-J; sets with these values: 2
